## Kconfig
```kconfig
menu "Zynq PL Config"
	#depends on ARM && AMBA
	depends on UIO

config ZED_UIO
	tristate "Synthesizer UIO module on Zedboard."
	help
	  Synthesizer UIO module.
endmenu
```
